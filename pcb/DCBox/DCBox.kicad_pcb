# Repository darkbull/DCBox

## KiCad design pcb/DCBox/DCBox.kicad_pcb

Parts:
C1, C2, C3, C11, C12, C13, C21, C22: NC; 0603_R
C4, C6: 4.7uF; 0603_R
C5, C7, C15, C16, C18, C20: 100nF; 0603_R
C8: 2.2uF; 0603_R
C9, C10: 1uF; 0603_R
C14, C17, C19: 22uF; 1206_R
D1, D2, D3, D4, D5, D6, D7: LED; 0603_LED_N1
H1, H2, H3, H4: MountingHole; MountingHole_2.2mm_M2
J1: Out-1; DC005
J2: Out-2; DC005
J3: Out-3; DC005
J4: DC-IN; DC005
J5: Out-4; DC005
J6, J7: USB_A; USB_A_Wuerth_614004134726_Horizontal
J8: Conn_01x04; PinHeader_1x04_P2.54mm_Vertical
L1: 10uH; L_Bourns-SRN6028
R1, R2, R3, R11, R15, R16: 1R/2W/%1; 2512_R
R4, R5, R6, R12, R21, R22, R23, R24, R25, R26, R28, R29, R31, R32: 1k; 0603_R
R7, R8, R9, R19, R20: 4.7k; 0603_R
R10: 560k; 0603_R
R13, R18: 20k; 0603_R
R14, R27: 10k; 0603_R
R17: 15k; 0603_R
R30: 1.5k; 0603_R
S1: OLED_091; ZJY09_Screen
SW1: SW_Push; Button_SW_THT_6.2x6.2
TH1: 16V/2A; 1812_R
U1: MT2492; SOT-23-6
U2: 662K; SOT-23-3L
U3: STC8H1K08_TSSOP20; TSSOP-20

Connections:
+3V3: C4.2, C5.2, C6.2, C7.2, C19.1, C20.1, R7.1, R8.1, R9.1, R19.1, R21.1, R22.1, R23.1, R24.1, R25.1, R26.1, S1.5 (VBAT), S1.8 (VDD), S1.14 (VCC), U2.2 (VCC), U3.8 (VCC/AVCC), U3.9 (ADC_Vref)
+5V: C17.1, C18.1, J6.1 (VBUS), J7.1 (VBUS), J8.1, L1.2, R17.1, R29.1, U2.3 (VIN)
+12V: C14.1, J1.1, J2.1, J3.1, J5.1, R13.1, R20.1, R27.1, TH1.1, U1.5 (IN)
/ADC_Current_DC1: C1.1, R4.2, U3.19 (P1.0/ADC0/RxD2)
/ADC_Current_DC2: C2.1, R5.2, U3.17 (P3.6/ADC14)
/ADC_Current_DC3: C3.1, R6.2, U3.16 (P3.5/ADC13)
/ADC_Current_DC4: C13.1, R12.2, U3.15 (P3.4/ADC12)
/ADC_Current_USB1: C11.1, R31.1, U3.14 (P3.3/ADC11)
/ADC_Current_USB2: C12.1, R32.1, U3.13 (P3.2/ADC10)
/ADC_Voltage_5V: C22.1, J8.4, R29.2, R30.1, U3.11 (P3.0/ADC8/RxD)
/ADC_Voltate_12V: C21.1, R27.2, R28.1, U3.20 (P1.1/ADC1/TxD2)
/Key_Config: C16.1, J8.3, R19.2, SW1.1, U3.12 (P3.1/ADC9/TxD)
/LED_DC1: D2.1 (K), U3.18 (P3.7/TxD2)
/LED_DC2: D3.1 (K), U3.3 (P1.4)
/LED_DC3: D4.1 (K), U3.4 (P1.5)
/LED_DC4: D5.1 (K), U3.5 (P1.6/RxD_3)
/LED_USB1: D6.1 (K), U3.6 (P1.7/TxD_3)
/LED_USB2: D7.1 (K), U3.7 (P5.4)
/SCL: R8.2, S1.10 (SCL), U3.1 (P1.2)
/SDA: R9.2, S1.11 (SDA), U3.2 (P1.3)
GND: C1.2, C2.2, C3.2, C4.1, C5.1, C6.1, C7.1, C8.1, C11.2, C12.2, C13.2, C14.2, C16.2, C17.2, C18.2, C19.2, C20.2, C21.2, C22.2, D1.1 (K), J4.2, J8.2, R1.1, R2.1, R3.1, R10.1, R11.1, R14.2, R15.2, R16.2, R18.2, R28.2, R30.2, S1.7 (VSS), SW1.2, U1.2 (GND), U2.1 (VSS), U3.10 (Gnd/AGnd)
unnamed: C8.2, S1.13 (VCOMH)
unnamed: C9.1, S1.2 (C2N)
unnamed: C9.2, S1.1 (C2P)
unnamed: C10.1, S1.4 (C1N)
unnamed: C10.2, S1.3 (C1P)
unnamed: C15.1, U1.1 (BS)
unnamed: C15.2, L1.1, U1.6 (SW)
unnamed: D1.2 (A), R20.2
unnamed: D2.2 (A), R21.2
unnamed: D3.2 (A), R22.2
unnamed: D4.2 (A), R23.2
unnamed: D5.2 (A), R24.2
unnamed: D6.2 (A), R25.2
unnamed: D7.2 (A), R26.2
unnamed: J1.2, R1.2, R4.1
unnamed: J2.2, R2.2, R5.1
unnamed: J3.2, R3.2, R6.1
unnamed: J4.1, TH1.2
unnamed: J5.2, R11.2, R12.1
unnamed: J6.4 (GND), J6.5 (Shield), R15.1, R31.2
unnamed: J7.4 (GND), J7.5 (Shield), R16.1, R32.2
unnamed: R7.2, S1.9 (RES#)
unnamed: R10.2, S1.12 (IREF)
unnamed: R13.2, R14.1, U1.4 (EN)
unnamed: R17.2, R18.1, U1.3 (FB)

Notes on the sheet:
4路12V DC5-2.1输出(最大1.4A) 2路 5V USB输出(最大1.4A)
Max: 2A

Board: 2 copper layers, 75.0 x 40.0 mm, 80 parts (60 on the bottom side), 46 nets.

## Commit log

2022-03-06 1. 添加PCB文件, 初始化。Kicad6，使用与Kicad5有区别，正在适应中。
2022-03-07 1. 完善原理图 2. 添加显示屏datasheet
2022-03-07 1. 完善布局
2022-03-08 1. 进线DC增加可恢复保险丝 2. 布局完善
2022-03-10 1. 布局基本完成
2022-03-11 1. 布线
2022-03-12 1. PCB基本完成
